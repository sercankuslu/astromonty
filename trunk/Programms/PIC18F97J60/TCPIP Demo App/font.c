#include "stdafx.h"
#include "font.h"

#define _M_(x,y) (WORD)((x<<8)+y)

#ifndef _WINDOWS
#include "GenericTypeDefs.h"
#pragma romdata overlay FONT_SECTION =0x00AC00
typedef struct SYMBOL {
    BYTE Size;
    WORD Image[];
}SYMBOL;
static rom 
#else
static
#endif
    WORD Arial_Data[] = {
    //_M_(0x01,3),0x002,0x005,0x002,                                            // ãðàäóñ
    _M_(' ',3),0x0000,0x000,0x0000,                       // ïðîáåë    
	_M_('!',1),0x02F,                                                    // !
	_M_('"',3),0x003,0x000,0x003,                                        // "
	_M_('#',6),0x024,0x07E,0x024,0x024,0x07E,0x024,                      // #
	_M_('$',5),0x024,0x04A,0x0FF,0x052,0x024,                            // $
	_M_('%',8),0x002,0x025,0x012,0x008,0x004,0x012,0x029,0x010,          // %
	_M_('&',7),0x010,0x02A,0x025,0x02D,0x012,0x038,0x024,                // &
	_M_('\'',1),0x003,                                                   // '
	_M_('(',2),0x07E,0x0C3,                                              // (
	_M_(')',2),0x0C3,0x07E,                                              // )
	_M_('*',7),0x00A,0x00A,0x004,0x01F,0x004,0x00A,0x00A,                // *
	_M_('+',3),0x008,0x01C,0x008,                                        // +
	_M_(',',2),0x100,0x080,                                              // ,
	_M_('-',3),0x008,0x008,0x008,                                        // -
	_M_('.',1),0x020,                                                    // .
	_M_('/',3),0x030,0x00C,0x003,                                        // /
	_M_('0',4),0x01E,0x021,0x021,0x01E,                                  // 0
	_M_('1',2),0x002,0x03F,                                              // 1
	_M_('2',4),0x022,0x031,0x029,0x026,                                  // 2
	_M_('3',4),0x012,0x021,0x025,0x01A,                                  // 3
	_M_('4',5),0x018,0x014,0x012,0x03F,0x010,                            // 4
	_M_('5',4),0x017,0x025,0x025,0x019,                                  // 5
	_M_('6',4),0x01E,0x025,0x025,0x019,                                  // 6
	_M_('7',4),0x001,0x039,0x005,0x003,                                  // 7
	_M_('8',4),0x01A,0x025,0x025,0x01A,                                  // 8
	_M_('9',4),0x026,0x029,0x029,0x01E,                                  // 9
	_M_(':',1),0x024,                                                    // :
	_M_(';',2),0x040,0x024,                                              // ;
	_M_('<',3),0x008,0x014,0x022,                                        // <
	_M_('=',4),0x014,0x014,0x014,0x014,                                  // =
	_M_('>',3),0x022,0x014,0x008,                                        // >
	_M_('?',3),0x002,0x029,0x006,                                        // ?
	_M_('@',8),0x038,0x044,0x092,0x0AA,0x0BA,0x0A2,0x09C,0x040,          // @
	_M_('A',4),0x03E,0x009,0x009,0x03E,                                  // A
	_M_('B',4),0x03F,0x025,0x025,0x01A,                                  // B
	_M_('C',4),0x01E,0x021,0x021,0x012,                                  // C
	_M_('D',4),0x03F,0x021,0x021,0x01E,                                  // D
	_M_('E',4),0x03F,0x025,0x025,0x021,                                  // E
	_M_('F',4),0x03F,0x005,0x005,0x001,                                  // F
	_M_('G',4),0x01E,0x021,0x029,0x03A,                                  // G
	_M_('H',4),0x03F,0x004,0x004,0x03F,                                  // H
	_M_('I',3),0x021,0x03F,0x021,                                        // I
	_M_('J',4),0x010,0x020,0x020,0x01F,                                  // J
	_M_('K',4),0x03F,0x004,0x00A,0x031,                                  // K
	_M_('L',4),0x03F,0x020,0x020,0x020,                                  // L
	_M_('M',5),0x03F,0x002,0x004,0x002,0x03F,                            // M
	_M_('N',4),0x03F,0x018,0x006,0x03F,                                  // N
	_M_('O',6),0x00C,0x012,0x021,0x021,0x012,0x00C,                      // O
	_M_('P',4),0x03F,0x009,0x009,0x006,                                  // P
	_M_('Q',6),0x00C,0x012,0x021,0x029,0x012,0x02C,                      // Q
	_M_('R',4),0x03F,0x009,0x009,0x036,                                  // R
	_M_('S',4),0x012,0x025,0x029,0x012,                                  // S
	_M_('T',5),0x001,0x001,0x03F,0x001,0x001,                            // T
	_M_('U',4),0x01F,0x020,0x020,0x01F,                                  // U
	_M_('V',5),0x003,0x00C,0x030,0x00C,0x003,                            // V
	_M_('W',9),0x003,0x00C,0x030,0x00C,0x003,0x00C,0x030,0x00C,0x003,    // W
	_M_('X',5),0x021,0x012,0x00C,0x012,0x021,                            // X
	_M_('Y',5),0x003,0x004,0x038,0x004,0x003,                            // Y
	_M_('Z',6),0x021,0x031,0x029,0x025,0x023,0x021,                      // Z
	_M_('[',2),0x0FF,0x081,                                              // [
	_M_('\\',3),0x003,0x03C,0x0C0,                                       /* \ */
	_M_(']',2),0x081,0x0FF,                                              // ]
	_M_('^',5),0x004,0x002,0x001,0x002,0x004,                            // ^
	_M_('_',5),0x080,0x080,0x080,0x080,0x080,                            // _
	_M_('`',3),0x002,0x005,0x002,                                        // `
	_M_('a',5),0x012,0x02A,0x02A,0x02A,0x03C,                            // a
	_M_('b',4),0x03F,0x024,0x024,0x018,                                  // b
	_M_('c',4),0x01C,0x022,0x022,0x022,                                  // c 
	_M_('d',4),0x018,0x024,0x024,0x03F,                                  // d
	_M_('e',5),0x01C,0x02A,0x02A,0x02A,0x004,                            // e
	_M_('f',3),0x004,0x03F,0x005,                                        // f
	_M_('g',4),0x09C,0x0A2,0x0A2,0x07E,                                  // g
	_M_('h',4),0x03F,0x004,0x004,0x038,                                  // h
	_M_('i',1),0x03D,                                                    // i
	_M_('j',2),0x080,0x27D,                                              // j
	_M_('k',4),0x03F,0x008,0x014,0x022,                                  // k
	_M_('l',1),0x03F,                                                    // l
	_M_('m',5),0x03E,0x002,0x03E,0x002,0x03C,                            // m
	_M_('n',4),0x03E,0x002,0x002,0x03C,                                  // n
	_M_('o',4),0x01C,0x022,0x022,0x01C,                                  // o
	_M_('p',4),0x0FE,0x022,0x022,0x01C,                                  // p
	_M_('q',4),0x01C,0x022,0x022,0x0FE,                                  // q
	_M_('r',4),0x03E,0x004,0x002,0x002,                                  // r
	_M_('s',4),0x024,0x02A,0x02A,0x012,                                  // s 
	_M_('t',3),0x002,0x01F,0x022,                                        // t
	_M_('u',4),0x01E,0x020,0x020,0x03E,                                  // u
	_M_('v',5),0x006,0x018,0x020,0x018,0x006,                            // v
	_M_('w',5),0x01E,0x020,0x01E,0x020,0x01E,                            // w
	_M_('x',4),0x032,0x00C,0x00C,0x032,                                  // x
	_M_('y',4),0x09E,0x0A0,0x0A0,0x07E,                                  // y
	_M_('z',4),0x032,0x02A,0x026,0x022,                                  // z
	_M_('{',3),0x010,0x06E,0x000,                                        // {
	_M_('|',1),0x0FF,                                                    // |
	_M_('}',3),0x081,0x06E,0x010,                                        // }
	_M_('~',5),0x008,0x004,0x004,0x008,0x004,                            // ~
	_M_('¨',5),0x03E,0x02B,0x02A,0x023,0x022,                            // ¨
	_M_('¸',5),0x01C,0x02B,0x02A,0x02B,0x004,                            // ¸
	_M_('À',4),0x03E,0x009,0x009,0x03E,                                  // À
	_M_('Á',5),0x03F,0x025,0x025,0x025,0x019,                            // Á
	_M_('Â',5),0x03F,0x025,0x025,0x025,0x01A,                            // Â
	_M_('Ã',5),0x03F,0x001,0x001,0x001,0x001,                            // Ã
	_M_('Ä',6),0x060,0x03E,0x021,0x021,0x03E,0x060,                      // Ä
	_M_('Å',5),0x03F,0x025,0x025,0x021,0x021,                            // Å
	_M_('Æ',7),0x031,0x00A,0x004,0x03F,0x004,0x00A,0x031,                // Æ
	_M_('Ç',4),0x021,0x025,0x025,0x01A,                                  // Ç
	_M_('È',5),0x03F,0x010,0x008,0x004,0x03F,                            // È
	_M_('É',5),0x03F,0x010,0x009,0x004,0x03F,                            // É
	_M_('Ê',4),0x03F,0x004,0x00A,0x031,                                  // Ê
	_M_('Ë',5),0x020,0x03F,0x001,0x001,0x03F,                            // Ë
	_M_('Ì',5),0x03F,0x002,0x004,0x002,0x03F,                            // Ì
	_M_('Í',4),0x03F,0x004,0x004,0x03F,                                  // Í 
	_M_('Î',6),0x00C,0x012,0x021,0x021,0x012,0x00C,                      // Î
	_M_('Ï',4),0x03F,0x001,0x001,0x03F,                                  // Ï
	_M_('Ð',4),0x03F,0x009,0x009,0x006,                                  // Ð
	_M_('Ñ',4),0x01E,0x021,0x021,0x021,                                  // Ñ
	_M_('Ò',5),0x001,0x001,0x03F,0x001,0x001,                            // Ò
	_M_('Ó',5),0x007,0x028,0x028,0x028,0x01F,                            // Ó
	_M_('Ô',5),0x00E,0x011,0x03F,0x011,0x00E,                            // Ô
	_M_('Õ',5),0x031,0x00A,0x004,0x00A,0x031,                            // Õ
	_M_('Ö',5),0x03F,0x020,0x020,0x03F,0x060,                            // Ö
	_M_('×',4),0x007,0x008,0x008,0x03F,                                  // ×
	_M_('Ø',5),0x03F,0x020,0x03F,0x020,0x03F,                            // Ø
	_M_('Ù',6),0x03F,0x020,0x03F,0x020,0x03F,0x060,                      // Ù
	_M_('Ú',5),0x001,0x03F,0x024,0x024,0x018,                            // Ú
	_M_('Û',5),0x03F,0x024,0x024,0x018,0x03F,                            // Û
	_M_('Ü',4),0x03F,0x024,0x024,0x018,                                  // Ü
	_M_('Ý',5),0x012,0x021,0x025,0x025,0x01E,                            // Ý
	_M_('Þ',6),0x03F,0x008,0x01E,0x021,0x021,0x01E,                      // Þ
	_M_('ß',5),0x036,0x009,0x009,0x009,0x03F,                            // ß
	_M_('à',5),0x012,0x02A,0x02A,0x02A,0x03C,                            // à
	_M_('á',4),0x01E,0x025,0x025,0x019,                                  // á
	_M_('â',5),0x03E,0x02A,0x02A,0x02A,0x014,                            // â
	_M_('ã',4),0x03E,0x002,0x002,0x002,                                  // ã
	_M_('ä',5),0x060,0x03C,0x022,0x03E,0x060,                            // ä
	_M_('å',5),0x01C,0x02A,0x02A,0x02A,0x024,                            // å
	_M_('æ',5),0x036,0x008,0x03E,0x008,0x036,                            // æ
	_M_('ç',4),0x022,0x02A,0x02A,0x014,                                  // ç
	_M_('è',4),0x03E,0x010,0x008,0x03E,                                  // è
	_M_('é',4),0x03C,0x011,0x009,0x03C,                                  // é
	_M_('ê',4),0x03E,0x008,0x008,0x036,                                  // ê
	_M_('ë',5),0x020,0x03E,0x002,0x002,0x03E,                            // ë
	_M_('ì',5),0x03E,0x004,0x008,0x004,0x03E,                            // ì
	_M_('í',4),0x03E,0x008,0x008,0x03E,                                  // í
	_M_('î',4),0x01C,0x022,0x022,0x01C,                                  // î
	_M_('ï',4),0x03E,0x002,0x002,0x03E,                                  // ï
	_M_('ð',4),0x03E,0x012,0x012,0x00C,                                  // ð
	_M_('ñ',4),0x01C,0x022,0x022,0x022,                                  // ñ
	_M_('ò',5),0x03E,0x002,0x03E,0x002,0x03C,                            // ò
	_M_('ó',4),0x09E,0x0A0,0x0A0,0x07E,                                  // ó
	_M_('ô',5),0x01C,0x022,0x07F,0x022,0x01C,                            // ô
	_M_('õ',4),0x032,0x00C,0x00C,0x032,                                  // õ
	_M_('ö',5),0x03E,0x020,0x020,0x03E,0x060,                            // ö
	_M_('÷',4),0x00E,0x010,0x010,0x03E,                                  // ÷
	_M_('ø',5),0x03E,0x020,0x03E,0x020,0x03E,                            // ø
	_M_('ù',6),0x03E,0x020,0x03E,0x020,0x03E,0x060,                      // ù
	_M_('ú',5),0x002,0x03E,0x024,0x024,0x018,                            // ú
	_M_('û',5),0x03E,0x024,0x024,0x018,0x03E,                            // û
	_M_('ü',4),0x03E,0x024,0x024,0x018,                                  // ü
	_M_('ý',5),0x014,0x022,0x02A,0x02A,0x01C,                            // ý
	_M_('þ',6),0x03E,0x008,0x01C,0x022,0x022,0x01C,                      // þ
	_M_('ÿ',5),0x02C,0x012,0x012,0x012,0x03E,                            // ÿ
};                                                                       
#ifndef _WINDOWS                                                         
static rom                                                               
#else                                                                    
static                                                                   
#endif                                                                   
    WORD Arial_B_Data[]={                                                
    0x000,0x000,0x000,0x000,0x000,                                       //
    0x0DF,0x0DE,                                                         //
    0x00B,0x007,0x000,0x00B,0x007,                                       //
    0x0E4,0x03C,0x027,0x0E4,0x03C,0x027,                                 //
    0x09C,0x132,0x3FF,0x132,0x0E4,                                       //
    0x00F,0x009,0x0CF,0x030,0x00C,0x0F3,0x090,0x0F0,                     //
    0x060,0x0F6,0x09F,0x099,0x0F7,0x0E6,0x0B0,                           //
    0x00B,0x007,                                                         //
    0x078,0x1FE,0x303,                                                   //
    0x303,0x1FE,0x078,                                                   //
    0x00A,0x007,0x00A,                                                   //
    0x010,0x010,0x07C,0x010,0x010,
    0x2C0,0x1C0,
    0x010,0x010,0x010,
    0x0C0,0x0C0,
    0x0C0,0x03C,0x003,
    0x07E,0x0FF,0x081,0x0FF,0x07E,
    0x00C,0x006,0x0FF,0x0FF,
    0x0C2,0x0E3,0x0B1,0x09F,0x08E,
    0x042,0x0C3,0x089,0x0FF,0x076,
    0x030,0x02C,0x022,0x0FF,0x0FF,0x020,
    0x05C,0x0CF,0x08B,0x0F9,0x071,
    0x07E,0x0FF,0x089,0x0FB,0x072,
    0x001,0x0F1,0x0FD,0x00F,0x003,
    0x076,0x0FF,0x089,0x0FF,0x076,
    0x04E,0x0DF,0x091,0x0FF,0x07E,
    0x0CC,0x0CC,
    0x2CC,0x1CC,
    0x018,0x018,0x024,0x024,0x042,
    0x028,0x028,0x028,0x028,0x008,
    0x042,0x024,0x024,0x018,0x018,
    0x002,0x0D3,0x0D9,0x00F,0x006,
    0x078,0x186,0x172,0x28D,0x285,0x2C5,0x2FD,0x28D,0x142,0x13C,
    0x0E0,0x0FC,0x03F,0x023,0x03F,0x0FC,0x0E0,
    0x0FF,0x0FF,0x089,0x089,0x0FF,0x076,
    0x03C,0x07E,0x0C3,0x081,0x081,0x0C3,0x042,
    0x0FF,0x0FF,0x081,0x081,0x0FF,0x07E,
    0x0FF,0x0FF,0x089,0x089,0x089,0x081,
    0x0FF,0x0FF,0x009,0x009,0x009,0x001,
    0x03C,0x07E,0x0C3,0x081,0x091,0x0F3,0x072,
    0x0FF,0x0FF,0x008,0x008,0x0FF,0x0FF,
    0x0FF,0x0FF,
    0x040,0x0C0,0x080,0x0FF,0x07F,
    0x0FF,0x0FF,0x018,0x03E,0x0F7,0x0C1,
    0x0FF,0x0FF,0x080,0x080,0x080,0x080,
    0x0FF,0x0FF,0x00F,0x07C,0x0E0,0x07C,0x00F,0x0FF,0x0FF,
    0x0FF,0x0FF,0x00C,0x030,0x0FF,0x0FF,
    0x03C,0x07E,0x0C3,0x081,0x0C3,0x07E,0x03C,
    0x0FF,0x0FF,0x011,0x011,0x01F,0x00E,
    0x03C,0x07E,0x0C3,0x0A1,0x0C3,0x0FE,0x13C,0x100,
    0x0FF,0x0FF,0x011,0x031,0x07F,0x0CE,0x080,
    0x04E,0x0CF,0x099,0x099,0x0F3,0x072,
    0x001,0x001,0x0FF,0x0FF,0x001,0x001,
    0x07F,0x0FF,0x080,0x080,0x0FF,0x07F,
    0x003,0x03F,0x0FC,0x0C0,0x0FC,0x03F,0x003,
    0x003,0x03F,0x0FC,0x0E0,0x03E,0x007,0x03E,0x0E0,0x0FC,0x03F,0x003,
    0x0C3,0x0E7,0x03C,0x03C,0x0E7,0x0C3,
    0x003,0x00F,0x0F8,0x0F8,0x00F,0x003,
    0x0C1,0x0E1,0x0B1,0x099,0x08D,0x087,0x083,
    0x3FF,0x3FF,0x201,
    0x003,0x03C,0x0C0,
    0x201,0x3FF,0x3FF,
    0x008,0x00E,0x003,0x00E,0x008,
    0x200,0x200,0x200,0x200,0x200,0x200,
    0x001,0x003,0x002,
    0x068,0x0F4,0x094,0x0FC,0x0F8,
    0x0FF,0x0FF,0x084,0x084,0x0FC,0x078,
    0x078,0x0FC,0x084,0x0CC,0x048,
    0x078,0x0FC,0x084,0x084,0x0FF,0x0FF,
    0x078,0x0FC,0x094,0x094,0x0DC,0x058,
    0x004,0x0FE,0x0FF,0x005,0x001,
    0x178,0x2FC,0x284,0x284,0x3FC,0x1FC,
    0x0FF,0x0FF,0x004,0x004,0x0FC,0x0F8,
    0x0FD,0x0FD,
    0x200,0x3FD,0x1FD,
    0x0FF,0x0FF,0x030,0x078,0x0EC,0x084,
    0x0FE,0x0FF,
    0x0FC,0x0FC,0x004,0x004,0x0FC,0x0FC,0x004,0x004,0x0FC,0x0F8,
    0x0FC,0x0FC,0x004,0x004,0x0FC,0x0F8,
    0x078,0x0FC,0x084,0x084,0x0FC,0x078,
    0x3FC,0x3FC,0x084,0x084,0x0FC,0x078,
    0x078,0x0FC,0x084,0x084,0x3FC,0x3FC,
    0x0FC,0x0FC,0x008,0x004,0x004,0x004,
    0x058,0x0DC,0x0B4,0x0B4,0x0EC,0x068,
    0x004,0x07E,0x0FF,0x084,
    0x07C,0x0FC,0x080,0x080,0x0FC,0x0FC,
    0x03C,0x0FC,0x0C0,0x0FC,0x03C,
    0x01C,0x0FC,0x0E0,0x078,0x00C,0x078,0x0E0,0x0FC,0x01C,
    0x0CC,0x0FC,0x030,0x0FC,0x0CC,
    0x204,0x23C,0x3F8,0x1C0,0x0F8,0x03C,0x004,
    0x0C4,0x0E4,0x0B4,0x09C,0x08C,
    0x020,0x1FE,0x000,0x201,
    0x3FF,
    0x201,0x3DF,0x1FE,0x020,
    0x010,0x008,0x008,0x010,0x008,
    0x0FE,0x0FF,0x092,0x092,0x083,0x082,
    0x078,0x0FD,0x094,0x094,0x0DD,0x058,
    0x0E0,0x0FC,0x03F,0x023,0x03F,0x0FC,0x0E0,
    0x0FF,0x0FF,0x089,0x089,0x089,0x0F9,0x070,
    0x0FF,0x0FF,0x089,0x089,0x0FF,0x076,
    0x0FF,0x0FF,0x001,0x001,0x001,
    0x380,0x0FF,0x0FF,0x081,0x0FF,0x0FF,0x380,
    0x0FF,0x0FF,0x089,0x089,0x081,
    0x081,0x0F3,0x07E,0x008,0x0FF,0x0FF,0x008,0x07E,0x0F3,0x081,
    0x042,0x0C3,0x089,0x089,0x0FF,0x076,
    0x0FF,0x0FF,0x060,0x030,0x018,0x0FF,0x0FF,
    0x0FF,0x0FF,0x060,0x033,0x018,0x0FF,0x0FF,
    0x0FF,0x0FF,0x008,0x07E,0x0F3,0x081,
    0x080,0x0FF,0x07F,0x001,0x001,0x0FF,0x0FF,
    0x0FF,0x0FF,0x00F,0x07C,0x0E0,0x07C,0x00F,0x0FF,0x0FF,
    0x0FF,0x0FF,0x008,0x008,0x0FF,0x0FF,
    0x03C,0x07E,0x0C3,0x081,0x0C3,0x07E,0x03C,
    0x0FF,0x0FF,0x001,0x001,0x001,0x0FF,0x0FF,
    0x0FF,0x0FF,0x011,0x011,0x01F,0x00E,
    0x03C,0x07E,0x0C3,0x081,0x081,0x0C3,0x042,
    0x001,0x001,0x0FF,0x0FF,0x001,0x001,
    0x003,0x08F,0x0FC,0x078,0x01F,0x007,
    0x03C,0x07E,0x042,0x0FF,0x0FF,0x042,0x07E,0x03C,
    0x0C3,0x0E7,0x03C,0x03C,0x0E7,0x0C3,
    0x0FF,0x0FF,0x080,0x080,0x0FF,0x0FF,0x380,
    0x00F,0x01F,0x010,0x010,0x010,0x0FF,0x0FF,
    0x0FF,0x0FF,0x080,0x080,0x0FF,0x0FF,0x080,0x080,0x0FF,0x0FF,
    0x0FF,0x0FF,0x080,0x080,0x0FF,0x0FF,0x080,0x080,0x0FF,0x0FF,0x380,
    0x001,0x001,0x0FF,0x0FF,0x088,0x088,0x088,0x0F8,0x070,
    0x0FF,0x0FF,0x088,0x088,0x088,0x0F8,0x070,0x0FF,0x0FF,
    0x0FF,0x0FF,0x088,0x088,0x088,0x0F8,0x070,
    0x024,0x066,0x0C3,0x089,0x0CB,0x07E,0x03C,
    0x0FF,0x0FF,0x018,0x03C,0x07E,0x0C3,0x081,0x0C3,0x07E,0x03C,
    0x080,0x0CE,0x07F,0x031,0x011,0x0FF,0x0FF,
    0x068,0x0F4,0x094,0x0FC,0x0F8,
    0x07E,0x0FD,0x085,0x085,0x0FD,0x079,
    0x0FC,0x0FC,0x094,0x094,0x0FC,0x068,
    0x0FC,0x0FC,0x004,0x004,
    0x380,0x0C0,0x0FC,0x084,0x0FC,0x0FC,0x380,
    0x078,0x0FC,0x094,0x094,0x0DC,0x058,
    0x0C4,0x0EC,0x010,0x0FC,0x0FC,0x010,0x0EC,0x0C4,
    0x048,0x084,0x094,0x0FC,0x068,
    0x0FC,0x0FC,0x060,0x018,0x0FC,0x0FC,
    0x0FC,0x0FD,0x061,0x019,0x0FD,0x0FC,
    0x0FC,0x0FC,0x010,0x078,0x0EC,0x084,
    0x080,0x0FC,0x07C,0x004,0x0FC,0x0FC,
    0x0FC,0x0FC,0x030,0x0C0,0x030,0x0FC,0x0FC,
    0x0FC,0x0FC,0x010,0x010,0x0FC,0x0FC,
    0x078,0x0FC,0x084,0x084,0x0FC,0x078,
    0x0FC,0x0FC,0x004,0x004,0x0FC,0x0FC,
    0x3FC,0x3FC,0x084,0x084,0x0FC,0x078,
    0x078,0x0FC,0x084,0x0CC,0x048,
    0x004,0x0FC,0x0FC,0x004,
    0x204,0x23C,0x3F8,0x1C0,0x0F8,0x03C,0x004,
    0x078,0x0FC,0x084,0x3FF,0x3FF,0x084,0x0FC,0x078,
    0x0CC,0x0FC,0x030,0x0FC,0x0CC,
    0x0FC,0x0FC,0x080,0x080,0x0FC,0x0FC,0x380,
    0x01C,0x03C,0x020,0x0FC,0x0FC,
    0x0FC,0x0FC,0x080,0x0FC,0x0FC,0x080,0x0FC,0x0FC,
    0x0FC,0x0FC,0x080,0x0FC,0x0FC,0x080,0x0FC,0x0FC,0x380,
    0x004,0x0FC,0x0FC,0x090,0x0F0,0x060,
    0x0FC,0x0FC,0x090,0x0F0,0x060,0x0FC,0x0FC,
    0x0FC,0x0FC,0x090,0x0F0,0x060,
    0x048,0x0CC,0x094,0x0FC,0x078,
    0x0FC,0x0FC,0x010,0x078,0x0FC,0x084,0x0FC,0x078,
    0x080,0x0D8,0x07C,0x024,0x0FC,0x0FC
};
#ifndef _WINDOWS
#pragma romdata
#endif

static WORD Arial_cp1251[256];
static WORD Arial_B_cp1251[256];

void InitFonts(void)
{
    WORD i = 0;
    WORD j = 0;
    //WORD b = 0;
    WORD_VAL c;
    static BYTE AlreadyInited = 0;
    if(AlreadyInited == 0){
        for(j=0;j<256;j++){
            c.Val = Arial_Data[i];
            Arial_cp1251[c.byte.HB] = i;
            i += c.byte.LB + 1;
        }
        i = 0;
        for(j=0;j<256;j++){
            Arial_B_cp1251[j] = i;
            i += Arial_B_Data[i] + 1;
        }
        AlreadyInited = 1;
    }
}

WORD* GetSymbolImage(BYTE symbol,WORD* OutWordCount,BYTE CFont){
    static WORD Image[12];
    BYTE i;        
    WORD Begin =  0;
    WORD End   =  0;    
    WORD Size =  0;
    WORD_VAL c;
    memset(Image,0,12);
    switch(CFont){
        case 0:
            Begin = Arial_cp1251[symbol];
            c.Val = Arial_Data[Begin];
            Size = c.byte.LB;
        break;
        case 1:
            Begin = Arial_B_cp1251[symbol+1];
            End   = Arial_B_cp1251[(symbol+1)];    
            Size = End - Begin;
        break;
        default:
            End   = 0;
            Begin = 0;
    }   
    //Image[0]=0;
    if(Size<1){
        (*OutWordCount) = 0;
        return 0;
    } 
     switch(CFont){
        case 0:
            //memcpy(Image,&Arial_Data[Begin],Size*sizeof(WORD));
            for(i=0;i<Size;i++){
                Image[i]= Arial_Data[Begin+i+1];
            }
        break;
        case 1:
            for(i=0;i<Size;i++){
                Image[i]= Arial_B_Data[Begin+i];
            }
        break;
     }   
    (*OutWordCount) = Size;
    return Image;//&ArialData[Begin];    
}

